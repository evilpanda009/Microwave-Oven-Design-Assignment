# Keil uVision project AD1674.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051 (all Variants) Generic
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: AD1674.OMF +hex
  c flags: Optimize=4 SizeSpeed=1
  group Source Group 1
    ./: AD1674.c
