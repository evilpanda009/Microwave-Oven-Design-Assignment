# Keil uVision project TIMER.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8032 (all Variants) Generic
  cpu: IRAM(0 - 0xFF) CLOCK(12000000)
  output: TIMER.OMF +hex
  c flags: Optimize=4
  group Source Group 1
    ./: Main.c Timer.c TaskProc.c
