# IAR project RTC_Time.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC2138 NXP LPC2138
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\INC\NXP; SRC
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: RTC_Time.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.elf
  ILINK.IlinkIcfFile: Config\RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ILINK.IlinkIcfFile: Config\Flash.icf
  group SRC
    SRC/: Target.c
  group USR
    USR/: RTC_Time.c
